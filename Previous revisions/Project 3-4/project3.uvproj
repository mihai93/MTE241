# Keil uVision project project3.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: project3
  c flags: Optim=1
  c define: __RTGT_UART
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup code
    ./: startup_LPC17xx.s
  group System code
    ./: system_LPC17xx.c GLCD.h GLCD_SPI_LPC1700.c Retarget.c
  group Source code
    ./: array_tools.c array_tools.h main.c quicksort.c quicksort.h uart.c RTX_Conf_CM.c uart.h
